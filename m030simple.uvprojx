# Keil uVision project m030simple.uvprojx, settings and files
target opt (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: M030GGD1AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.21
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: m030simple +hex
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c include: .\src\Device\Nuvoton\M030G\Include;.\src\CMSIS\Include;.\src\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_M030G.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ./src/Device/Nuvoton/M030G/Source/: system_M030G.c
    ./src/Device/Nuvoton/M030G/Source/ARM/: startup_M030G.s
  group Driver
    ./src/StdDriver/src/: adc.c bpwm.c clk.c crc.c dac.c fmc.c gpio.c i2c.c manch.c pdma.c retarget.c spi.c sys.c timer.c uart.c wdt.c wwdt.c
  group User
    ./src/: main.c i2cslave.c i2cmaster.c timer.c
